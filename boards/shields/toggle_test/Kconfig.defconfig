## boards/shields/toggle_test/Kconfig.defconfig
```kconfig
if SHIELD_TOGGLE_TEST

config ZMK_KEYBOARD_NAME
    default "toggle-test"

endif # SHIELD_TOGGLE_TEST
```
